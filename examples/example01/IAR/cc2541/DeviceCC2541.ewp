# IAR project DeviceCC2541.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: __CC2541__
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: config; ../../app; ../../../../; ../../../../common; ../../../../common/lib; ../../../../common/sys; ../../../../common/sys/pt; ../../../../common/hal/mcu/cc254x
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2541F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group APP
    ../../app/: leds.c
  group HAL/CC254x
    ../../../../common/hal/mcu/cc254x/: clocks.c gpio.c hal.c timers.c
  group SYS
    ../../../../common/sys/: devtime.c stimer.c task.c
