# IAR project DeviceSTM32F042F4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F042x4 ST STM32F042x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F042x6
  ICCARM.CCIncludePath2: ../../app; config; ../../../../; ../../../../common; ../../../../common/lib; ../../../../common/sys; ../../../../common/sys/pt; ../../../../common/hal; ../../../../common/hal/mcu/stm32f0x; ../../../../common/hal/mcu/stm32f0x/CMSIS/Device/ST/STM32F0xx/Include; ../../../../common/hal/mcu/stm32f0x/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DeviceSTM32F042F4.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  ICCARM.CCDefines: STM32F042x6; NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
    ../../../../common/hal/mcu/stm32f0x/CMSIS/Device/ST/STM32F0xx/Include/: stm32f042x6.h
  group APP
    ../../app/: leds.c
  group HAL/STM32F0x
    ../../../../common/hal/mcu/stm32f0x/: clocks.c gpio.c hal.c timers.c
  group SYS
    ../../../../common/sys/: devtime.c stimer.c task.c
