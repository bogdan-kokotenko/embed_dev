# IAR project DeviceG2553.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: config; ../../app; ../../../../; ../../../../common; ../../../../common/lib; ../../../../common/sys; ../../../../common/sys/pt; ../../../../common/hal/mcu/msp430g2x
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430g2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ./: main.c
  group APP
    ../../app/: leds.c
  group HAL/MSP430G2x
    ../../../../common/hal/mcu/msp430g2x/: clocks.c gpio.c hal.c timers.c
  group SYS
    ../../../../common/sys/: devtime.c stimer.c task.c
