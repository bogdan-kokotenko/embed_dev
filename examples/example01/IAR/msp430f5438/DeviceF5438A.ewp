# IAR project DeviceF5438A.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: config; ../../app; ../../../../; ../../../../common; ../../../../common/lib; ../../../../common/sys; ../../../../common/sys/pt; ../../../../common/hal/mcu/msp430f5x; ../../../../common/hal/mcu/msp430f5x/F5xx_F6xx_Core_Lib
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ./: main.c
  group APP
    ../../app/: leds.c
  group HAL/MSP430F5x
    ../../../../common/hal/mcu/msp430f5x/: clocks.c gpio.c hal.c timers.c
  group HAL/MSP430F5x/F5xx_F6xx_Core_Lib
    ../../../../common/hal/mcu/msp430f5x/F5xx_F6xx_Core_Lib/: HAL_PMM.c HAL_TLV.c HAL_UCS.c
  group SYS
    ../../../../common/sys/: devtime.c stimer.c task.c
